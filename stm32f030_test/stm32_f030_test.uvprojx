# Keil uVision project stm32_f030_test.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: STM32F030F4Px STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.1.1
  cpu: IRAM(0x20000000,0x00001000) IROM(0x08000000,0x00004000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: stm32_f030_test
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=1 wLevel=4
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group main
    ./: main.c
  group GPIO
    ./: GPIO.c GPIO.h GPIO_cfg.c GPIO_types.h GPIO_cfg.h
  group TM1637_Display
    ./: TM1637.c TM1637.h
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.0
